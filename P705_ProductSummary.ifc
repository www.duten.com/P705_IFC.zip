Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: fa477b46-1040-40aa-a2b7-2643392a1b42, NumberOfSaves: 68], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2024-07-05T15:11:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 05 15:11:31 2024 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\771be0ad-a090-408d-9bac-76592f37ad6d\d9fcad12-0b80-4dfd-bf0a-8e20e36bac01\ifc * Database version: 5507 * Database creation date: Fri Jul 05 15:11:26 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 05 15:11:27 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 05 15:11:27 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
In: n/a
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: DBLTD_Duten_WasteBins_P705:Wall Mounted Bin, DBLTD_Duten_WasteBins_P705:Wall Mounted Bin:462559
In: Level 0
Type - PredefinedType: USERDEFINED; Material: DBLTD_Duten_Metal_BrushedStainlessSteel
Type - Pset_ElementShading - Color: Brushed Stainless Steel
Type - Pset_ManufacturerTypeInformation - ModelReference: Wall Mounted Bin; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Bin; Category: Generic Models
Type - Pset_ProvisionForVoid - Shape: Other
Pset_BuildingElementProxyCommon - Reference: Wall Mounted Bin; sets with these values: 2
